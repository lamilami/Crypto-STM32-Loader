# Keil uVision project Frame.uvprojx, settings and files
target stm32f103vc (ARM-ADS)
  device: STM32F103VF STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0xC0000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Frame +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Application\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\FatFSR0.11;..\Libraries\CMSIS\startup;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\ini\dev;..\Libraries\tropicssl-tropicssl\include;..\Libraries\tropicssl-tropicssl\programs\ssl\test-ca\newcerts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group application
    ../Application/src/: main.c stm32f10x_it.c hardware_config.c stm_loader.c uart.c card_utl.c
  group library
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ../Libraries/tropicssl-tropicssl/library/: aes.c
  group FatFs
    ../Libraries/FatFSR0.11/: ff.c mmc_32f1.c
  group notice
    ../: notice.txt
  group ini
    ../Libraries/ini/dev/: minIni.c
