# IAR project Custom_HID.ewp, settings and files
configuration INCOTEX_Loader (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Application\inc; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\FatFSR0.11; ..\Libraries\ini\dev; ..\Libraries\IAP; ..\Libraries\tropicssl-tropicssl\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: INCO_TACHO_Loader.bin
  ILINK.IlinkOutputFile: Custom_HID.out
  ILINK.IlinkIcfFile: Custom_HID.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: stm32f10x_flash.icf
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group FatFS
    ../Libraries/FatFSR0.11/: ccsbcs.c diskio.c ff.c
  group ini
    ../Libraries/ini/dev/: minIni.c
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group tssl
    ../Libraries/tropicssl-tropicssl/library/: aes.c
  group User
    ../Application/src/: card_utl.c hardware_config.c main.c stm32f10x_it.c stm_loader.c system_stm32f10x.c uart.c
