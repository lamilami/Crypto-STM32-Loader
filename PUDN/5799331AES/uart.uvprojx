# Keil uVision project uart.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uart +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s core_cm3.c system_LPC17xx.c
  group app
    ./: uart.c main.c
  group AES
    ./: aes.c
